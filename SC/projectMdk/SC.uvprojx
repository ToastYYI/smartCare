# Keil uVision project SC.uvprojx, settings and files
target SC (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SC
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030 USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\user;..\startup;..\lib\inc;..\CoOS\kernel;..\CoOS\portable
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group user
    ../user/: App.c adc.c gpio.c stm32f0xx_it.c sys.c usart.c wdog.c ringbuffer.c pwm.c ringbuf.c
  group startup
    ./RTE/: startup_stm32f030x6.s
    ../startup/: system_stm32f0xx.c
  group lib
    ../lib/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group os
    ../CoOS/kernel/: core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c queue.c sem.c serviceReq.c task.c time.c timer.c utility.c
  group os/port
    ../CoOS/portable/Keil/: port.c
    ../CoOS/portable/: arch.c
