# IAR project SC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\startup; ..\user; ..\lib\inc; ..\CoOS\kernel; ..\CoOS\portable
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SC.hex
  ILINK.IlinkOutputFile: zmdo-8..out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: Programming_ble.out
  group lib
    ../lib/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group os
    ../CoOS/kernel/: core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c queue.c sem.c serviceReq.c task.c time.c timer.c utility.c
  group os/port
    ../CoOS/portable/: arch.c
    ../CoOS/portable/IAR/: portForM0.asm
  group startup
    ../startup/: startup_stm32f030.s system_stm32f0xx.c
  group user
    ../user/: adc.c App.c flash.c gpio.c led.c pwm.c ringbuf.c stm32f0xx_it.c sys.c usart.c wdog.c
